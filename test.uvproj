# Keil uVision project test.uvproj, settings and files
target ThermostaticBath (MCS-51)
  device: STC12C5A60S2 STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group serialport
    ./: uart.c
  group main
    ./: main.c
  group timer0
    ./: timer0.c
  group delay
    ./: delay.c
  group display
    ./: led.c lcd12864.c
  group memory
    ./: at24c02.c
